# Keil uVision project 不利用数组来进行动态数码管的显示.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 不利用数组来进行动态数码管的显示 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 不利用数组来进行动态数码管的显示.c
