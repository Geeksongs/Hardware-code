# Keil uVision project _crol_函数实现流水灯.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: _crol_函数实现流水灯 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: _crol_函数实现流水灯.c
